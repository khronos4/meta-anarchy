SRC_URI += "file://cubieboard2.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"