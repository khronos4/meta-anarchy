DESCRIPTION = "RTKLIB is an open source program package for standard and precise positioning with GNSS (global navigation satellite system)"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://readme.txt;md5=e612690af2f575dfd02e2e91443cea23"

SRC_URI = "http://www.rtklib.com/prog/${PN}_${PV}.zip"

S = "${WORKDIR}/${PN}_${PV}"
